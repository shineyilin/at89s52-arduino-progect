# Keil uVision project z51_board.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: z51_board +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: show.c STARTUP.A51 main.c uart.c ir_func.c multiservo.c
  group Inc
    ./: show.h include.h com_define.h uart.h ir_func.h multiservo.h
